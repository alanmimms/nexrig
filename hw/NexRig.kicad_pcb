# Repository alanmimms/nexrig (continued)

## KiCad design hw/NexRig.kicad_pcb (continued)

Schematic: rx-presel.kicad_sch, Rx Digitally Tuned Preselector

Parts:
C7866, C7867, C7870: 1uF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
C7868: 8pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H080D080AA; Mouser Part Number 810-CGA3E2C0G1H080D
C7869: 15pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H150J080AA; Mouser Part Number 810-CGA3E2C0G1H150J
C7871: 33pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H330J080AA; Mouser Part Number 810-CGA3E2C0G1H330J
C7872: 68pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H680J080AA; Mouser Part Number 810-CGA3E2C0G1H680J
C7873: 120pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H121J080AA; Mouser Part Number 810-CGA3E2C0G1H121J
C7874: 250pF; C_0603_1608Metric; Manufacturer_Part_Number 06035A251JAT2A; Mouser Part Number 581-06035A251J
C7875: 560pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H561J080AA; Mouser Part Number 810-CGA3E2C0G1H561J
C7876: 1nF; C_0603_1608Metric; Manufacturer_Part_Number C1608C0G1H102J080AA; Mouser Part Number 810-C1608C0G1H102J
C7877: 2.2nF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H222J080AE; Mouser Part Number 810-CGA3E2C0G1H222J8
C7878: 3.9nF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H392J080AA; Mouser Part Number 810-CGA3E2C0G1H392J
C7879: 8.2nF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H822J080AE; Mouser Part Number 810-CGA3E2C0G1H822J8
L7703: 820nH; L_1210_3225Metric
L7704: 220nH; L_1210_3225Metric
R7767, R7768, R7769, R7770, R7771, R7772, R7773, R7774, R7775, R7776, R7777, R7778, R7779, R7780, R7781, R7782, R7783, R7784, R7785, R7786, R7787, R7788, R7789, R7790: 1k; R_0402_1005Metric
U7728, U7729: SN74LVC04APW; PW14
U7730, U7732, U7733, U7734, U7735, U7736, U7737, U7738, U7739, U7740, U7741, U7742: AS183-92LF; SOT65P220X110-6N; Mouser Part Number 873-AS183-92LF
U7731: MCP23S17; QFN65P600X600X100-29N-D; Mouser Part Number 579-MCP23S17T-E/ML

Connections:
+3.3V: C7866.2, C7867.2, C7870.2, U7728.14 (VCC), U7729.14 (VCC), U7731.5 (VDD), U7731.11 (A0); also elsewhere on the board
/Rx Front End/Rx Preselector/C0: R7783.2, U7728.1 (1A), U7730.4 (V1)
/Rx Front End/Rx Preselector/C1: R7784.2, U7728.3 (2A), U7732.4 (V1)
/Rx Front End/Rx Preselector/C2: R7785.2, U7728.5 (3A), U7733.4 (V1)
/Rx Front End/Rx Preselector/C3: R7786.2, U7728.9 (4A), U7734.4 (V1)
/Rx Front End/Rx Preselector/C4: R7787.2, U7728.11 (5A), U7735.4 (V1)
/Rx Front End/Rx Preselector/C5: R7788.2, U7728.13 (6A), U7736.4 (V1)
/Rx Front End/Rx Preselector/C6: R7789.2, U7729.1 (1A), U7737.4 (V1)
/Rx Front End/Rx Preselector/C7: R7790.2, U7729.3 (2A), U7738.4 (V1)
/Rx Front End/Rx Preselector/C8: R7778.2, U7729.5 (3A), U7739.4 (V1)
/Rx Front End/Rx Preselector/C9: R7779.2, U7729.9 (4A), U7740.4 (V1)
/Rx Front End/Rx Preselector/C10: R7780.2, U7729.11 (5A), U7741.4 (V1)
/Rx Front End/Rx Preselector/Ctrl.tuneMOSI: U7731.9 (SI)
/Rx Front End/Rx Preselector/Ctrl.tuneNSS: U7731.7 (~CS)
/Rx Front End/Rx Preselector/Ctrl.tuneRCK: U7731.8 (SCK)
/Rx Front End/Rx Preselector/Ctrl.tuneSCK: U7731.10 (SO)
/Rx Front End/Rx Preselector/L1: R7782.2, U7742.4 (V1)
/Rx Front End/Rx Preselector/dC0: R7783.1, U7731.17 (GPA0)
/Rx Front End/Rx Preselector/dC1: R7784.1, U7731.18 (GPA1)
/Rx Front End/Rx Preselector/dC2: R7785.1, U7731.19 (GPA2)
/Rx Front End/Rx Preselector/dC3: R7786.1, U7731.20 (GPA3)
/Rx Front End/Rx Preselector/dC4: R7787.1, U7731.21 (GPA4)
/Rx Front End/Rx Preselector/dC5: R7788.1, U7731.22 (GPA5)
/Rx Front End/Rx Preselector/dC6: R7789.1, U7731.23 (GPA6)
/Rx Front End/Rx Preselector/dC7: R7790.1, U7731.24 (GPA7)
/Rx Front End/Rx Preselector/dC8: R7778.1, U7731.25 (GPB0)
/Rx Front End/Rx Preselector/dC9: R7779.1, U7731.26 (GPB1)
/Rx Front End/Rx Preselector/dC10: R7780.1, U7731.27 (GPB2)
/Rx Front End/Rx Preselector/dL1: R7782.1, U7731.4 (GPB7)
/Rx Front End/Rx Preselector/nC0: R7767.2, U7730.6 (V2)
/Rx Front End/Rx Preselector/nC1: R7768.2, U7732.6 (V2)
/Rx Front End/Rx Preselector/nC2: R7769.2, U7733.6 (V2)
/Rx Front End/Rx Preselector/nC3: R7770.2, U7734.6 (V2)
/Rx Front End/Rx Preselector/nC4: R7771.2, U7735.6 (V2)
/Rx Front End/Rx Preselector/nC5: R7772.2, U7736.6 (V2)
/Rx Front End/Rx Preselector/nC6: R7773.2, U7737.6 (V2)
/Rx Front End/Rx Preselector/nC7: R7774.2, U7738.6 (V2)
/Rx Front End/Rx Preselector/nC8: R7775.2, U7739.6 (V2)
/Rx Front End/Rx Preselector/nC9: R7776.2, U7740.6 (V2)
/Rx Front End/Rx Preselector/nC10: R7777.2, U7741.6 (V2)
/Rx Front End/Rx Preselector/nL1: R7781.2, U7742.6 (V2)
/Rx Front End/rf200atten: U7730.1 (J3), U7732.1 (J3), U7733.1 (J3), U7734.1 (J3), U7735.1 (J3), U7736.1 (J3), U7737.1 (J3), U7738.1 (J3), U7739.1 (J3), U7740.1 (J3), U7741.1 (J3), U7742.3 (J2); also elsewhere on the board
unnamed: R7767.1, U7728.2 (1Y)
unnamed: R7768.1, U7728.4 (2Y)
unnamed: R7769.1, U7728.6 (3Y)
unnamed: R7770.1, U7728.8 (4Y)
unnamed: R7771.1, U7728.10 (5Y)
unnamed: R7772.1, U7728.12 (6Y)
unnamed: R7773.1, U7729.2 (1Y)
unnamed: R7774.1, U7729.4 (2Y)
unnamed: R7775.1, U7729.6 (3Y)
unnamed: R7776.1, U7729.8 (4Y)
unnamed: R7777.1, U7729.10 (5Y)
unnamed: C7868.1, U7730.5 (J1)
unnamed: R7781.1, U7731.3 (GPB6)
unnamed: C7869.1, U7732.5 (J1)
unnamed: C7871.1, U7733.5 (J1)
unnamed: C7872.1, U7734.5 (J1)
unnamed: C7873.1, U7735.5 (J1)
unnamed: C7874.1, U7736.5 (J1)
unnamed: C7875.1, U7737.5 (J1)
unnamed: C7876.1, U7738.5 (J1)
unnamed: C7877.1, U7739.5 (J1)
unnamed: C7878.1, U7740.5 (J1)
unnamed: C7879.1, U7741.5 (J1)
unnamed: L7703.1, U7742.5 (J1)
unnamed: L7703.2, L7704.1, U7742.1 (J3)
nRESET: U7731.14 (~RESET); also elsewhere on the board

Notes on the sheet:
Note L1/nL1 is software managed to save an inverter. When active, the 820nH inductor is bypassed leaving only 220nH in the preselector. When inactive, both are in series.
SPI 001

Schematic: tx-bridge.kicad_sch, GaN FET Transmitter Bridge

Parts:
C7753: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
C7754: 220nF; C_0603_1608Metric; Manufacturer_Part_Number GXT155R71E223KE01D; Mouser Part Number 81-GXT155R71E223KE1D
C7755, C7756: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
C7757: 1uF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
D7702: B120-E3; D_SMA
Q7701, Q7702: EPC2207; EPC2207-GaN-FET; Manufacturer_Part_Number IGB110S101XTMA1
U7709: LMG1210RVRR; RVR0019A

Connections:
/FPGA/TxDrive.baseL+: U7709.18 (HI_EN); also elsewhere on the board
/FPGA/TxDrive.baseL-: U7709.19 (PWM_LI); also elsewhere on the board
/Tx Chain/Base L GaN FET Bridge/out: C7754.2, Q7701.2 (S), Q7701.4 (S), Q7701.6 (S), Q7702.3 (D), Q7702.5 (D), U7709.9 (HS), U7709.13 (HS), U7709.14 (HS), U7709.16 (HS), U7709.21 (HS_DAP); also elsewhere on the board
unnamed: C7754.1, D7702.1 (K), U7709.12 (HB)
unnamed: Q7701.1 (G), U7709.10 (HO)
unnamed: Q7702.1 (G), U7709.8 (LO)
Veer: Q7701.3 (D), Q7701.5 (D); also elsewhere on the board

Parts of its further copies:
C7794, C7799, C7804: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
C7795, C7800, C7805: 220nF; C_0603_1608Metric; Manufacturer_Part_Number GXT155R71E223KE01D; Mouser Part Number 81-GXT155R71E223KE1D
C7796, C7797, C7801, C7802, C7806, C7807: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
C7798, C7803, C7808: 1uF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
D7704, D7705, D7706: B120-E3; D_SMA
Q7703, Q7704, Q7705, Q7706, Q7707, Q7708: EPC2207; EPC2207-GaN-FET; Manufacturer_Part_Number IGB110S101XTMA1
U7713, U7714, U7715: LMG1210RVRR; RVR0019A

Connections of its further copies:
/FPGA/TxDrive.baseR+: U7713.18 (HI_EN); also elsewhere on the board
/FPGA/TxDrive.baseR-: U7713.19 (PWM_LI); also elsewhere on the board
/FPGA/TxDrive.peakL+: U7714.18 (HI_EN); also elsewhere on the board
/FPGA/TxDrive.peakL-: U7714.19 (PWM_LI); also elsewhere on the board
/FPGA/TxDrive.peakR+: U7715.18 (HI_EN); also elsewhere on the board
/FPGA/TxDrive.peakR-: U7715.19 (PWM_LI); also elsewhere on the board
/Tx Chain/Base R GaN FET Bridge/out: C7795.2, Q7703.2 (S), Q7703.4 (S), Q7703.6 (S), Q7704.3 (D), Q7704.5 (D), U7713.9 (HS), U7713.13 (HS), U7713.14 (HS), U7713.16 (HS), U7713.21 (HS_DAP); also elsewhere on the board
/Tx Chain/Peak L GaN FET Bridge/out: C7800.2, Q7705.2 (S), Q7705.4 (S), Q7705.6 (S), Q7706.3 (D), Q7706.5 (D), U7714.9 (HS), U7714.13 (HS), U7714.14 (HS), U7714.16 (HS), U7714.21 (HS_DAP); also elsewhere on the board
/Tx Chain/Peak R GaN FET Bridge/out: C7805.2, Q7707.2 (S), Q7707.4 (S), Q7707.6 (S), Q7708.3 (D), Q7708.5 (D), U7715.9 (HS), U7715.13 (HS), U7715.14 (HS), U7715.16 (HS), U7715.21 (HS_DAP); also elsewhere on the board
unnamed: C7795.1, D7704.1 (K), U7713.12 (HB)
unnamed: C7800.1, D7705.1 (K), U7714.12 (HB)
unnamed: C7805.1, D7706.1 (K), U7715.12 (HB)
unnamed: Q7703.1 (G), U7713.10 (HO)
unnamed: Q7704.1 (G), U7713.8 (LO)
unnamed: Q7705.1 (G), U7714.10 (HO)
unnamed: Q7706.1 (G), U7714.8 (LO)
unnamed: Q7707.1 (G), U7715.10 (HO)
unnamed: Q7708.1 (G), U7715.8 (LO)
Veer: Q7703.3 (D), Q7703.5 (D), Q7705.3 (D), Q7705.5 (D), Q7707.3 (D), Q7707.5 (D); also elsewhere on the board

Notes on the sheet:
place top side between HB,HS
place top side between LMG1210 VDD,VSS pins

Schematic: tx-LPFs.kicad_sch, Transmit LPFs

Parts:
C7880, C7881, C7892: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
C7882, C7886, C7889: 47pF; C_0805_2012Metric; Manufacturer_Part_Number CC0805JRNPOCBN470; Mouser Part Number 603-CC0805JRCBN470
C7883, C7890: 27pF; C_0805_2012Metric; Manufacturer_Part_Number KGM21ECG3A270JU; Mouser Part Number 581-KGM21ECG3A270JU
C7884, C7891: 180pF; C_0805_2012Metric; Manufacturer_Part_Number C0805C181JDGACAUTO; Mouser Part Number 80-C0805C181JDGACATO
C7885: 82pF; C_0805_2012Metric; Manufacturer_Part_Number C0805C820JDGACTU; Mouser Part Number 80-C0805C820JDG
C7887: 270pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H271J080AA; Mouser Part Number 810-CGA3E2C0G1H271J
C7888: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
K7704, K7705, K7706, K7707, K7708, K7709: G5Q-14-05; Relay_SPDT_Omron-G5Q-1
L7705, L7708: 2.2uH; T68-toroid-1-rolling-tire
L7706, L7709: 1.2uH; T68-toroid-1-rolling-tire
L7707, L7710: 8.2uH; T68-toroid-1-rolling-tire
U7743: TPIC6C595PWR; SOP65P640X120-16N; Mouser Part Number 595-TPIC6C595PWR

Connections:
/FPGA/Ctrl.switchRCK: U7743.10 (RCK); also elsewhere on the board
/FPGA/Ctrl.switchSCK: U7743.15 (SRCK); also elsewhere on the board
/Tx Chain/Tx LPFs/enHiA: K7706.1, U7743.5 (DRAIN2)
/Tx Chain/Tx LPFs/enHiB: K7709.1, U7743.12 (DRAIN5)
/Tx Chain/Tx LPFs/enLowA: K7705.1, U7743.3 (DRAIN0)
/Tx Chain/Tx LPFs/enLowB: K7707.1, U7743.6 (DRAIN3)
/Tx Chain/Tx LPFs/enMidA: K7704.1, U7743.4 (DRAIN1)
/Tx Chain/Tx LPFs/enMidB: K7708.1, U7743.11 (DRAIN4)
/Tx Chain/Tx LPFs/serOut: U7743.9 (SER_OUT)
/Tx Chain/lpfB: K7707.3, K7708.3, K7709.3; also elsewhere on the board
/Tx Chain/tunerSerOut: U7743.2 (SER_IN); also elsewhere on the board
unnamed: C7882.1, K7704.2, L7705.1
unnamed: C7883.1, K7706.2, L7706.1
unnamed: C7884.1, K7705.2, L7707.1
unnamed: C7885.1, L7705.2, L7708.1
unnamed: C7886.1, L7706.2, L7709.1
unnamed: C7887.1, L7707.2, L7710.1
unnamed: C7889.1, K7708.2, L7708.2
unnamed: C7890.1, K7709.2, L7709.2
unnamed: C7891.1, K7707.2, L7710.2

Notes on the sheet:
High 17-10m 35.0MHz
Low 160-80m 5.5MHz
Mid 60-20m 18.0MHz

Schematic: ant-tuner.kicad_sch, Antenna Tuner

Parts:
C7792: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
C7793: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
D7703: 1N4148W; D_SOD-123
K7703: G5Q-14-05; Relay_SPDT_Omron-G5Q-1
U7712: TPIC6C595PWR; SOP65P640X120-16N; Mouser Part Number 595-TPIC6C595PWR

Connections:
/FPGA/Ctrl.switchRCK: U7712.10 (RCK); also elsewhere on the board
/FPGA/Ctrl.switchSCK: U7712.15 (SRCK); also elsewhere on the board
/Tx Chain/Antenna Tuner/C8: U7712.13 (DRAIN6)
/Tx Chain/Antenna Tuner/Chot: K7703.2; also elsewhere on the board
/Tx Chain/Antenna Tuner/Tuner Inductors/serOut: U7712.2 (SER_IN); also elsewhere on the board
/Tx Chain/Antenna Tuner/ant: K7703.4; also elsewhere on the board
/Tx Chain/Antenna Tuner/preC: D7703.2 (A), K7703.1, U7712.3 (DRAIN0)
/Tx Chain/Antenna Tuner/rig: K7703.3; also elsewhere on the board
/Tx Chain/tunerSerOut: U7712.9 (SER_OUT); also elsewhere on the board
/Tx Chain/txON: U7712.14 (DRAIN7); also elsewhere on the board

Notes on the sheet:
Relays NEVER switch except at 0V because we calculate L and C needed a priori from Bruene sampler complex impedance.
Bypass is achieved by deselecting all L (shorting them) and all C (disconnecting them).

Schematic: ethernet.kicad_sch

Parts:
C7959, C7960: 8.2pF; C_0402_1005Metric; Manufacturer_Part_Number GJM1555C1H8R2FB01D; Mouser Part Number 81-GJM1555C1H8R2FB1D
C7961, C7965, C7966, C7967, C7968, C7969: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
C7962: 1uF; C_0603_1608Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
C7963: 470pF; C_0603_1608Metric; Manufacturer_Part_Number C1608C0G1H471J080AA; Mouser Part Number 810-C1608C0G1H471J
C7964: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
C7970: 1nF; C_0603_1608Metric; Manufacturer_Part_Number KAF15AR71H102KM; Mouser Part Number 581-KAF15AR71H102KM
FB7704: BLM21AG102SN1D; L_0805_2012Metric; MfgPart BLM21AG102SN1D
J7707: RJ45_Abracon_ARJP11A-MASA-B-A-EMU2; RJ45_Abracon_ARJP11A-MA_Horizontal
R7858, R7863, R7865, R7866, R7867, R7877: 10k; R_0402_1005Metric
R7859, R7860, R7861, R7862: 33; R_0603_1608Metric
R7864: 100k; R_0402_1005Metric
R7868, R7869: 0; R_0603_1608Metric
R7870, R7871, R7873, R7874: 49.9; R_0603_1608Metric
R7872: 12.1k; R_0603_1608Metric
R7875, R7876: 270; R_0805_2012Metric
U7765: LAN8742A; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_ThermalVias
U7766: USBLC6-4SC6; SOT-23-6
Y7703: ECS-250-8-37B2-RWN; ECS2033250BN; Mouser Part Number 520-2033-250-BN

Connections:
+3.3V-ON: C7961.1, FB7704.1, R7863.2, R7864.2, R7865.2, R7866.2, R7867.2, U7765.9 (VDDIO); also elsewhere on the board
/microcontroller/EthCLK: R7859.1; also elsewhere on the board
/microcontroller/EthCRS_DV: R7862.1; also elsewhere on the board
/microcontroller/EthMDC: U7765.13 (MDC); also elsewhere on the board
/microcontroller/EthMDIO: R7864.1, U7765.12 (MDIO); also elsewhere on the board
/microcontroller/EthRXD0: R7860.1; also elsewhere on the board
/microcontroller/EthRXD1: R7861.1; also elsewhere on the board
/microcontroller/EthTXD0: U7765.17 (TXD0); also elsewhere on the board
/microcontroller/EthTXD1: U7765.18 (TXD1); also elsewhere on the board
/microcontroller/EthTxEnable: U7765.16 (TXEN); also elsewhere on the board
/microcontroller/Ethernet/EthRx+: J7707.3 (RD+), R7873.2, U7765.23 (RXP), U7766.1 (I/O1)
/microcontroller/Ethernet/EthRx-: J7707.6 (RD-), R7874.2, U7765.22 (RXN), U7766.6 (I/O4)
/microcontroller/Ethernet/EthTx+: J7707.1 (TD+), R7870.2, U7765.21 (TXP), U7766.3 (I/O2)
/microcontroller/Ethernet/EthTx-: J7707.2 (TD-), R7871.2, U7765.20 (TXN), U7766.4 (I/O3)
/microcontroller/Ethernet/EthVDDA: C7964.1, C7965.1, C7966.1, C7967.1, FB7704.2, R7870.1, R7871.1, R7873.1, R7874.1, U7765.1 (VDD2A), U7765.19 (VDD1A), U7766.5 (VBUS)
/microcontroller/Ethernet/LEDGA: J7707.13, R7877.1, U7765.2 (LED2/~INTSEL)
/microcontroller/Ethernet/LEDYA: J7707.11, U7765.3 (LED1/REGOFF)
unnamed: C7959.2, R7868.1, Y7703.3
unnamed: C7960.2, R7869.1, Y7703.1
unnamed: C7970.1, J7707.7
unnamed: J7707.12, R7875.1
unnamed: J7707.14, R7876.1
unnamed: C7968.1, C7969.1, J7707.4 (TCT), J7707.5 (RCT)
unnamed: R7862.2, R7865.1, U7765.11 (CRS_DV/MODE2)
unnamed: R7872.2, U7765.24 (RBIAS)
unnamed: R7860.2, R7867.1, U7765.8 (RXD0/MODE0)
unnamed: R7861.2, R7866.1, U7765.7 (RXD1/MODE1)
unnamed: R7858.2, U7765.10 (RXER/PHYAD0)
unnamed: C7962.1, C7963.1, U7765.6 (VDDCR)
unnamed: R7868.2, U7765.5 (XTAL1/CLKIN)
unnamed: R7869.2, U7765.4 (XTAL2)
unnamed: R7859.2, R7863.1, U7765.14 (~INT/REFCLKO)
nRESET: U7765.15 (~RST); also elsewhere on the board

Schematic: eer-buckboost.kicad_sch, Tx Envelope Buck/Boost Converter

Parts:
C7919: 10nF; C_0603_1608Metric; Manufacturer_Part_Number GCM1885C2A103JE02J; Mouser Part Number 81-GCM1885C2A103JE2J
C7920, C7925, C7926, C7931: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
C7921: 10uF; C_0603_1608Metric; Manufacturer_Part_Number 81-GXT155R71E223KE1D; Mouser Part Number 963-MLAST168BB5106MT
C7922, C7930: 100pF; C_0603_1608Metric; Manufacturer_Part_Number CGA3E2C0G1H101J080AE; Mouser Part Number 810-CGA3E2C0G1H101JA
C7923: 3.3nF; C_0603_1608Metric; Manufacturer_Part_Number C1608C0G1H332J080AE; Mouser Part Number 810-C1608C0G1H332J08
C7924: 4.7uF; C_0805_2012Metric; Manufacturer_Part_Number 08055D475KAT4A; Mouser Part Number 581-08055D475KAT4A
C7927: 1uF; C_0402_1005Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
C7928, C7929: 220nF; C_0603_1608Metric; Manufacturer_Part_Number C0603X224J5RACTU; Mouser Part Number 80-C0603X224J5RTU
C7932: 220pF; C_0603_1608Metric; Manufacturer_Part_Number C1608C0G1H221F080AA; Mouser Part Number 810-C1608C0G1H221F
C7933, C7934: 10uF; C_0805_2012Metric; Manufacturer_Part_Number TAJD106K050RNJ; Mouser Part Number 581-TAJD106K050R
C7935: 470pF; C_0603_1608Metric; Manufacturer_Part_Number C1608C0G1H471J080AA; Mouser Part Number 810-C1608C0G1H471J
C7936, C7937, C7938, C7939, C7941: 1uF; C_0603_1608Metric; Manufacturer_Part_Number GRM155R61E105KE11D; Mouser Part Number 81-GRM155R61E105KE1D
C7940, C7942: 10uF; C_1206_3216Metric; Manufacturer_Part_Number A759KS106M2CAAE110; Mouser Part Number 80-A759KS106M2CAE110
D7716, D7717: DFLS1200-7; DFLS12007; Mouser Part Number 621-DFLS1200-F
L7722: 6.8uH; Bourns PQ2614BLA-6R8K
NT7701, NT7702: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q7709, Q7710, Q7711, Q7712: BSC360N15NS3 G; Infineon_PG-TDSON-8_6.15x5.15mm
R7809, R7817: 100k; R_0402_1005Metric
R7810, R7818: 3.53k; R_0603_1608Metric
R7811: 649k; R_0603_1608Metric
R7812, R7813, R7816: 10k; R_0402_1005Metric
R7814: 13k; R_0603_1608Metric
R7815: 125k; R_0603_1608Metric
R7819: 107k; R_0603_1608Metric
R7820, R7821: 1k; R_0603_1608Metric
R7822: 5; R_0603_1608Metric
R7823, R7824, R7827, R7828: 100; R_0603_1608Metric
R7825, R7826, R7830, R7831: 2; R_0603_1608Metric
R7829: 5m; CSS2H3920K5L00F; Mouser Part Number 652-CSS2H-3920K5L00F
U7755: TLV9062xD; SOIC-8_3.9x4.9mm_P1.27mm
U7756: NVTFS6H888NLTAG; WDFN_8NLTAG_ONS
U7757: LTC3779IFE#PBF; SOP50P640X120-39N; Mouser Part Number 584-LTC3779IFEPBF
U7758: PCT2075DP; TSSOP-8_3x3mm_P0.65mm

Connections:
+3.3V: C7927.1, R7813.1, U7758.8 (VCC); also elsewhere on the board
+5VA: C7919.1, C7920.1, C7921.1, U7755.8 (V+); also elsewhere on the board
/Power/Tx EER Envelope Buck-Boost/BG1: R7826.1, U7757.1 (BG1)
/Power/Tx EER Envelope Buck-Boost/BG2: R7831.1, U7757.19 (BG2)
/Power/Tx EER Envelope Buck-Boost/Ctrl.tmpSCL: U7758.2 (SCL)
/Power/Tx EER Envelope Buck-Boost/Ctrl.tmpSDA: U7758.1 (SDA)
/Power/Tx EER Envelope Buck-Boost/FB: C7930.2, R7819.2, U7755.1, U7757.10 (VFB)
/Power/Tx EER Envelope Buck-Boost/IAVGSNSN: C7935.2, R7827.1
/Power/Tx EER Envelope Buck-Boost/IAVGSNSP: C7935.1, R7828.1, U7757.26 (IAVGSNSP), U7757.28 (IAVGSNSN)
/Power/Tx EER Envelope Buck-Boost/SENSEN: C7932.1, R7824.1, U7757.12 (SENSEN)
/Power/Tx EER Envelope Buck-Boost/SENSEP: C7932.2, R7823.1, U7757.11 (SENSEP)
/Power/Tx EER Envelope Buck-Boost/SOFTSTART: U7757.9 (SS)
/Power/Tx EER Envelope Buck-Boost/SW1: C7929.1, L7722.1, Q7709.1 (S), Q7709.2 (S), Q7709.3 (S), Q7710.5 (D), U7757.38 (SW1)
/Power/Tx EER Envelope Buck-Boost/SW2: C7928.2, L7722.2, Q7711.1 (S), Q7711.2 (S), Q7711.3 (S), Q7712.5 (D), U7757.20 (SW2)
/Power/Tx EER Envelope Buck-Boost/TG1: R7825.1, U7757.37 (TG1)
/Power/Tx EER Envelope Buck-Boost/TG2: R7830.1, U7757.21 (TG2)
/Power/TxAmplitude: R7816.1; also elsewhere on the board
/Power/TxEnable: U7757.24 (RUN); also elsewhere on the board
/Power/TxPGOOD: R7813.2, U7757.18 (PGOOD); also elsewhere on the board
/Power/scaledEERVdd: U7755.6 (-), U7755.7; also elsewhere on the board
unnamed: C7923.1, R7814.2
unnamed: C7924.1, C7925.1, D7716.2 (A), D7717.2 (A), U7756.1 (S), U7756.2 (S), U7756.3 (S), U7757.7 (DRVCC)
unnamed: C7928.1, D7716.1 (K), U7757.22 (BOOST2)
unnamed: C7929.2, D7717.1 (K), U7757.36 (BOOST1)
unnamed: NT7701.1, R7823.2, R7827.2
unnamed: NT7701.2, Q7710.1 (S), Q7710.2 (S), Q7710.3 (S), Q7712.1 (S), Q7712.2 (S), Q7712.3 (S), R7829.2
unnamed: NT7702.1, R7824.2, R7828.2
unnamed: Q7709.4 (G), R7825.2
unnamed: Q7710.4 (G), R7826.2
unnamed: Q7711.4 (G), R7830.2
unnamed: Q7712.4 (G), R7831.2
unnamed: R7817.1, R7818.2, U7755.3 (+)
unnamed: C7930.1, R7816.2, R7819.1, U7755.2 (-)
unnamed: R7809.1, R7810.2, U7755.5 (+)
unnamed: U7756.4 (G), U7757.6 (NDRV)
unnamed: C7926.1, U7757.3 (DRVSET), U7757.8 (V5), U7757.15 (MODE)
unnamed: R7815.1, U7757.17 (FREQ)
unnamed: C7922.1, R7814.1, U7757.13 (ITH)
unnamed: C7931.2, R7822.2, U7757.34 (VIN)
unnamed: R7811.2, R7812.1, U7757.2 (VINOV)
unnamed: R7820.2, U7757.32 (VINSNS)
unnamed: R7821.1, U7757.30 (VOUTSNS)
VBUS: C7933.1, C7934.1, C7936.1, C7937.1, C7938.1, C7939.1, C7941.1, Q7709.5 (D), R7820.1, R7822.1, U7756.5 (D), U7756.6 (D), U7756.7 (D), U7756.8 (D); also elsewhere on the board
Veer: C7940.1, C7942.1, Q7711.5 (D), R7809.2, R7811.1, R7817.2, R7821.2; also elsewhere on the board

Notes on the sheet:
500kHz switching
Low ESR ceramic. Close to MOSFETs.
Scale 0..85V to 0..3V
Disable if VOUT > 85V
Isat >= 11A
~8ms soft start
Temperature sensor 000. Place as close as possible to big FETs.
Low ESR polymer.

Schematic: power-priority.kicad_sch, Power Priority Switching

Parts:
C7957, C7958: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
Q7714, Q7715, Q7716, Q7717: IPB026N06NATMA1; Mouser Part Number 726-IPB026N06NATMA1
R7847, R7850, R7852, R7854: 100k; R_0402_1005Metric
R7848: 4.7k; R_0603_1608Metric
R7849: 8.2k; R_0603_1608Metric
R7851: 12.4k; R_0603_1608Metric
R7853: 15k; R_0603_1608Metric
R7855: 39k; R_0603_1608Metric
R7856: 27k; R_0603_1608Metric
R7857: 3.3k; R_0603_1608Metric
U7763, U7764: LM74800QDRRRQ1; SON50P300X300X80-13N; Mouser Part Number 595-LM74800QDRRRQ1

Connections:
+12V: Q7714.3 (S), U7763.2 (A), U7763.3 (VSNS); also elsewhere on the board
/Power/Power Priority/EN_UVLO1: R7850.2, R7851.1, U7763.6 (EN/UVLO)
/Power/Power Priority/EN_UVLO2: R7854.2, R7855.1, U7764.6 (EN/UVLO)
/Power/Power Priority/OV1: R7848.2, R7849.1, U7763.5 (OV)
/Power/Power Priority/OV2: R7852.2, R7853.1, U7764.5 (OV)
/Power/Power Priority/SW1: R7847.1, U7763.4 (SW)
/Power/Power Priority/SW2: U7764.4 (SW)
/Power/Power Priority/VBATT1: Q7714.2 (D), Q7715.3 (S), R7850.1, R7852.1, U7763.10 (VS), U7763.12 (C)
/Power/Power Priority/VBATT2: Q7716.2 (D), Q7717.3 (S), U7764.10 (VS), U7764.12 (C)
/Power/mon12V: R7847.2, R7848.1; also elsewhere on the board
/Power/monUSBPD: R7856.2, R7857.1; also elsewhere on the board
unnamed: Q7714.1 (G), U7763.1 (DGATE)
unnamed: Q7715.1 (G), U7763.8 (HGATE)
unnamed: Q7716.1 (G), U7764.1 (DGATE)
unnamed: Q7717.1 (G), U7764.8 (HGATE)
unnamed: C7957.1, U7763.11 (CAP)
unnamed: C7958.1, U7764.11 (CAP)
VBUS: Q7715.2 (D), Q7717.2 (D), U7763.9 (OUT), U7764.9 (OUT); also elsewhere on the board
VUSBPD: Q7716.3 (S), R7854.1, R7856.1, U7764.2 (A), U7764.3 (VSNS); also elsewhere on the board

Notes on the sheet:
Cut off above 16.5V
Wake up at 10.87V
Disable if USBPD < 4V.
Enabled when +12V is out of range.

Schematic: usb-pd.kicad_sch

Parts:
C7949: 4.7uF; C_0805_2012Metric; Manufacturer_Part_Number 08055D475KAT4A; Mouser Part Number 581-08055D475KAT4A
C7952, C7953: 4.7uF; C_0805_2012Metric; Manufacturer_Part_Number 298D475X9010M2T; Mouser Part Number 74-298D475X9010M2T
C7955: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
D7722: MMQA33VT1G; SC-74-6_1.55x2.9mm_P0.95mm; Mouser Part Number 863-MMQA33VT1G
J7706: USB C power only; UJ20CHGMSMT4P16TR; Mouser Part Number 179-UJ20CHGMSMT4P16T
Q7713: SQJ433EP; PowerPAK_SO-8L_Single
R7832, R7835: 1k; R_0603_1608Metric
R7833, R7838: 100k; R_0402_1005Metric
R7834: 22.1k; R_0603_1608Metric
R7836: 100; R_0603_1608Metric
R7837: 0.005; R_0612_1632Metric
R7839: 10k; R_0402_1005Metric
U7759: STUSB4500QTR; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+2.7V: C7953.1, U7759.23 (VREG_2V7)
+3.3V-ON: R7839.1; also elsewhere on the board
/FPGA/Ctrl.tmpSCL: U7759.7 (SCL); also elsewhere on the board
/FPGA/Ctrl.tmpSDA: U7759.8 (SDA); also elsewhere on the board
/FPGA/Ctrl.usbPOK2: U7759.20 (POWER_OK2); also elsewhere on the board
/FPGA/Ctrl.usbPOK3: U7759.14 (POWER_OK3); also elsewhere on the board
/FPGA/Ctrl.usbReset: R7838.1, U7759.6 (RESET)
/FPGA/Ctrl.usbnALERT: R7839.2, U7759.19 (ALERT); also elsewhere on the board
/Power/USB-PD/CC1: D7722.4 (K_3), J7706.A5 (CC1), U7759.1 (CC1DB), U7759.2 (CC1)
/Power/USB-PD/CC2: D7722.6 (K_4), J7706.B5 (CC2), U7759.4 (CC2), U7759.5 (CC2DB)
/Power/USB-PD/VBUS_DISCH: R7832.2, U7759.18 (VBUS_VS_DISCH)
unnamed: C7955.2, R7836.2
unnamed: C7949.1, D7722.1 (K_1), J7706.A4 (VBUS_1), J7706.B4 (VBUS_2), Q7713.1 (S), Q7713.2 (S), Q7713.3 (S), R7832.1, R7833.1, U7759.24 (VDD)
unnamed: C7955.1, Q7713.5 (D), R7835.2, R7837.2
unnamed: Q7713.4 (G), R7833.2, R7834.1, R7836.1
unnamed: R7835.1, U7759.9 (DISCH)
unnamed: R7834.2, U7759.16 (VBUS_EN_SNK)
unnamed: C7952.1, U7759.21 (VREG_1V2)
VUSBPD: D7722.3 (K_2), R7837.1; also elsewhere on the board

Schematic: tuner-caps.kicad_sch, Antenna Tuner Capacitors

Parts:
C7943: 4.7pF; C_0805_2012Metric; Manufacturer_Part_Number 0805Y1K04P70DCT; Mouser Part Number 766-0805Y1K04P70DCT
C7944: 82pF; C_0805_2012Metric; Manufacturer_Part_Number C0805C820JDGACTU; Mouser Part Number 80-C0805C820JDG
C7945: 10pF; C_1206_3216Metric; Manufacturer_Part_Number CC0805JRNPOCBN100; Mouser Part Number 603-CC0805JRNPOCBN10
C7946: 160pF; C_0805_2012Metric; Manufacturer_Part_Number C0805C161GDGACAUTO; Mouser Part Number 80-C0805C161GDGACATO
C7947: 20pF; C_1206_3216Metric; Manufacturer_Part_Number CC1206JKNPOCBN200; Mouser Part Number 603-CC1206JNPOCBN200
C7948: 330pF; C_1206_3216Metric; Manufacturer_Part_Number CC1206JKNPOCBN331; Mouser Part Number 603-CC126JKNPOCBN331
C7950: 39pF; C_1206_3216Metric; Manufacturer_Part_Number CC1206JKNPOCBN390; Mouser Part Number 603-CC1206JKCBN390
C7951: 680pF; C_1206_3216Metric; Manufacturer_Part_Number CC1206JKNPOCBN681; Mouser Part Number 603-CC126JKNPOCBN681
C7954: 1.2nF; C_1210_3225Metric; Manufacturer_Part_Number CGA6M1C0G3A122J200AC; Mouser Part Number 810-CGA6M1C0G3A1J2A
C7956: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
D7718, D7719, D7720, D7721, D7723, D7724, D7725, D7726, D7727: 1N4148W; D_SOD-123
K7718, K7719, K7720, K7721, K7722, K7723, K7724, K7725, K7726: G5Q-14-05; Relay_SPDT_Omron-G5Q-1
U7760: TPIC6C595PWR; SOP65P640X120-16N; Mouser Part Number 595-TPIC6C595PWR

Connections:
/FPGA/Ctrl.switchMOSI: U7760.2 (SER_IN); also elsewhere on the board
/FPGA/Ctrl.switchRCK: U7760.10 (RCK); also elsewhere on the board
/FPGA/Ctrl.switchSCK: U7760.15 (SRCK); also elsewhere on the board
/Tx Chain/Antenna Tuner/Chot: K7718.3, K7719.3, K7720.3, K7721.3, K7722.3, K7723.3, K7724.3, K7725.3, K7726.3; also elsewhere on the board
/Tx Chain/Antenna Tuner/Tuner Capacitors/C0: U7760.3 (DRAIN0)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C1: U7760.4 (DRAIN1)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C2: U7760.5 (DRAIN2)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C3: U7760.6 (DRAIN3)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C4: U7760.11 (DRAIN4)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C5: U7760.12 (DRAIN5)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C6: U7760.13 (DRAIN6)
/Tx Chain/Antenna Tuner/Tuner Capacitors/C7: U7760.14 (DRAIN7)
/Tx Chain/Antenna Tuner/Tuner Capacitors/serOut: U7760.9 (SER_OUT); also elsewhere on the board
unnamed: C7943.1, K7718.2
unnamed: C7944.1, K7719.2
unnamed: C7945.1, K7720.2
unnamed: C7946.1, K7721.2
unnamed: C7947.1, K7722.2
unnamed: C7948.1, K7723.2
unnamed: C7950.1, K7724.2
unnamed: C7951.1, K7725.2
unnamed: C7954.1, K7726.2
unnamed: D7718.2 (A), K7718.1
unnamed: D7719.2 (A), K7719.1
unnamed: D7720.2 (A), K7720.1
unnamed: D7721.2 (A), K7721.1
unnamed: D7723.2 (A), K7722.1
unnamed: D7724.2 (A), K7723.1
unnamed: D7725.2 (A), K7724.1
unnamed: D7726.2 (A), K7725.1
unnamed: D7727.2 (A), K7726.1

Notes on the sheet:
Relays shown in fully deselected configuration as normally closed.

Schematic: tuner-inductors.kicad_sch, Antenna Tuner Inductors

Parts:
C7893: 100nF; C_0603_1608Metric; Manufacturer_Part_Number C0805F104K1RACAUTO; Mouser Part Number 80-C0805F104K1RAUTO
D7707, D7708, D7709, D7710, D7711, D7712, D7713, D7714: 1N4148W; D_SOD-123
K7710, K7711, K7712, K7713, K7714, K7715, K7716, K7717: G5Q-14-05; Relay_SPDT_Omron-G5Q-1
L7711: 32uH; T130-toroid-1-rolling-tire
L7712: 16uH; T106-toroid-1-rolling-tire
L7713: 8uH; T80-toroid-1-rolling-tire
L7714: 4uH; T80-toroid-1-rolling-tire
L7715: 2uH; T68-toroid-1-rolling-tire
L7716: 1uH; T50-toroid-1-rolling-tire
L7717: 0.5uH; T50-toroid-1-rolling-tire
L7718: 0.25uH; T50-toroid-1-rolling-tire
U7744: TPIC6C595PWR; SOP65P640X120-16N; Mouser Part Number 595-TPIC6C595PWR

Connections:
/FPGA/Ctrl.switchRCK: U7744.10 (RCK); also elsewhere on the board
/FPGA/Ctrl.switchSCK: U7744.15 (SRCK); also elsewhere on the board
/Tx Chain/Antenna Tuner/Tuner Capacitors/serOut: U7744.2 (SER_IN); also elsewhere on the board
/Tx Chain/Antenna Tuner/Tuner Inductors/L0: D7714.2 (A), K7717.1, U7744.3 (DRAIN0)
/Tx Chain/Antenna Tuner/Tuner Inductors/L1: D7713.2 (A), K7716.1, U7744.4 (DRAIN1)
/Tx Chain/Antenna Tuner/Tuner Inductors/L2: D7712.2 (A), K7715.1, U7744.5 (DRAIN2)
/Tx Chain/Antenna Tuner/Tuner Inductors/L3: D7711.2 (A), K7714.1, U7744.6 (DRAIN3)
/Tx Chain/Antenna Tuner/Tuner Inductors/L4: D7710.2 (A), K7713.1, U7744.11 (DRAIN4)
/Tx Chain/Antenna Tuner/Tuner Inductors/L5: D7709.2 (A), K7712.1, U7744.12 (DRAIN5)
/Tx Chain/Antenna Tuner/Tuner Inductors/L6: D7708.2 (A), K7711.1, U7744.13 (DRAIN6)
/Tx Chain/Antenna Tuner/Tuner Inductors/L7: D7707.2 (A), K7710.1, U7744.14 (DRAIN7)
/Tx Chain/Antenna Tuner/Tuner Inductors/serOut: U7744.9 (SER_OUT); also elsewhere on the board
/Tx Chain/Antenna Tuner/ant: K7717.4, L7718.2; also elsewhere on the board
/Tx Chain/Antenna Tuner/rig: K7710.2, L7711.1; also elsewhere on the board
unnamed: K7710.4, K7711.2, L7711.2, L7712.1
unnamed: K7711.4, K7712.2, L7712.2, L7713.1
unnamed: K7712.4, K7713.2, L7713.2, L7714.1
unnamed: K7713.4, K7714.2, L7714.2, L7715.1
unnamed: K7714.4, K7715.2, L7715.2, L7716.1
unnamed: K7715.4, K7716.2, L7716.2, L7717.1
unnamed: K7716.4, K7717.2, L7717.2, L7718.1

Notes on the sheet:
NOTE: This shorts out the transmitter if used in Lshunt configuration!
Relays shown in full bypass configuration normally closed.

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
Board: 6 copper layers, 664 parts (0 on the bottom side), 494 nets, no tracks yet.

Other parts of the board:
K7702: TQ2-5V-functional; RELAY_TQ2_PAN
R7722: 220; R_0603_1608Metric

Their connections:
/Rx Front End/RxZ200: K7702.3 (T1); also elsewhere on the board
/Tx Chain/txON: K7702.10 (COIL-); also elsewhere on the board
unnamed 312: R7722.1; also elsewhere on the board
