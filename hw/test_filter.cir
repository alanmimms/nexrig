.title Chebyshev Bandpass Filter
* Generated by coupled-resonator-filter.py
* Center frequency: 15.803 MHz
* Bandwidth: 5.000 MHz

* Input source (50 ohm)
Vin in 0 AC 1
Rin in 1 50

* Input matching network (tapped capacitor)
Chot_in 1 2 202.41p
Ccold_in 2 0 101.20p

* Tank 1
L1 2 0 1000.0n
C1 2 0 101.42p

* Coupling capacitor 1-2
C12 2 3 20.147p

* Tank 2
L2 3 0 1000.0n
C2 3 0 101.42p

* Coupling capacitor 2-3
C23 3 4 20.147p

* Tank 3
L3 4 0 1000.0n
C3 4 0 101.42p

* Output matching network (tapped capacitor)
Ccold_out 4 0 101.20p
Chot_out 4 5 202.41p

* Output load (50 ohm)
Rload 5 0 50

.end
